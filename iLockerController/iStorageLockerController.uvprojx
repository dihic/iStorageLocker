# Keil uVision project iStorageLockerController.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iStorageLockerController +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HSE_VALUE=25000000, DEBUG_PRINT
  c misc: --gnu
  c include: .\bson;.\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Sources
    ./: main.cpp System.c ConfigComm.cpp NetworkConfig.cpp CanDevice.cpp StorageUnit.cpp CommStructures.cpp UnitManager.cpp NetworkEngine.cpp TcpClient.cpp SimpleFS.cpp Audio.cpp UartComm.cpp
  group BSON
    ./bson/: BsonBinary.cpp BsonCString.cpp BsonDocument.cpp BsonString.cpp Element.cpp Guid.cpp MemStream.cpp TypeInfoBase.cpp
  group Driver
    ./: CanEx.cpp s25fl064.cpp UsbKeyboard.cpp tas5727.cpp vs10xx.cpp
  group CDriver
    ./: CAN_STM32F40x.c Driver_CAN.c
target Release (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: as above
  output: iStorageLockerController +hex
  c flags: Optim=1 oTime=1 uC99=1 wLevel=2
  c define: HSE_VALUE=25000000
  c misc: --gnu
  c include: .\bson;.\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Network:CORE 6.4.0, Network:Interface:ETH 6.4.0, Network:Socket:TCP 6.4.0, USB:CORE 6.4.0, USB:Host 6.4.0, USB:Host:HID 6.4.0, CMSIS Driver:Ethernet:KSZ8851SNL 6.02, CMSIS Driver:I2C 2.02, CMSIS Driver:SPI 2.02, CMSIS Driver:USART 2.01, CMSIS Driver:USB Host:Full-speed 2.07, CMSIS Driver:USB Host:High-speed 2.07, Compiler:I/O:STDERR 1.0.0, Compiler:I/O:STDOUT 1.0.0, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:CAN 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:Flash 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:I2C 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:RNG 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:STM32Cube HAL:UART 1.1.0, Device:STM32Cube HAL:USART 1.1.0, Device:Startup 2.1.0
